## sdkconfig.defaults
```kconfig
# set hz=1000
CONFIG_FREERTOS_HZ=1000

# Reduce bootloader log verbosity
CONFIG_BOOTLOADER_LOG_LEVEL_WARN=y
CONFIG_BOOTLOADER_LOG_LEVEL=2
```
